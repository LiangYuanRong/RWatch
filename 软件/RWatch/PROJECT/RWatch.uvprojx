# Keil uVision project RWatch.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RWatch +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\FWLIB\inc;..\CMSIS;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\led;..\HARDWARE\buzzer;..\HARDWARE\button;..\HARDWARE\oled;..\USER\TASK;..\HARDWARE\timer;..\HARDWARE\rtc;..\HARDWARE\iic;..\HARDWARE\pcf8563
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../USER/: stm32f10x_it.c
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../START_UP/: startup_stm32f10x_md.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/led/: LED.c
    ../HARDWARE/buzzer/: buzzer.c
    ../HARDWARE/button/: button.c
    ../HARDWARE/oled/: oled.c oledfont.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/rtc/: rtc.c
    ../HARDWARE/iic/: iic.c
    ../HARDWARE/pcf8563/: pcf8563.c
  group USER
    ../USER/: main.c
  group TASK
    ../USER/TASK/: GUI.c
